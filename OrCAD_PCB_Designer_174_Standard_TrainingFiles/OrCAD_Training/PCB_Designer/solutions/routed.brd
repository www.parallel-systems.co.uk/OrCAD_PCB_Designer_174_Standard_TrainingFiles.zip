# Allegro board routed.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEMORY.RA12: length 274.6
  TOP w0.15: U21.19 114.48,86.2 ; 114.48,86.2 116.56,86.2 118.14,84.61 118.14,72.99 118.01,72.86 v1(118.01,72.13) ; 114.48,86.2 113.97,85.68 113.97,80.27 114.48,79.75 U20.19 ; v1(97.53,99.06) 96.72,98.25 96.72,86.8 v1(95.78,85.86) ; U19.19 v1(90.48,112.56) ; U23.19 114.48,118.41 117.43,118.41 118.44,117.39 v1(118.44,101.87) 117.71,101.14 116.14,101.14 114.48,102.79 U22.19 ; v1(78.32,73.41) 80.45,73.41 80.84,73.01 80.84,67.52 83.13,65.23 v1(118.01,65.23) ; U18.19 v1(90.48,102.53) ; v1(68.93,93.59) 68.05,94.46 U5.62 ; U17.19 90.48,90.03 90.7,90.03 v1(90.7,89.3) 92.36,87.65 92.36,80.7 91.96,80.31 91.85,80.31 91.22,79.67 91.22,76.99 90.96,76.73 90.68,76.73 90.48,76.93 U16.19
  BOTTOM w0.15: v1(78.32,73.41) 78.32,74.14 78.52,74.33 78.52,79.94 78.32,80.13 78.32,85.96 82.51,90.16 89.85,90.16 v1(90.7,89.3) 93.28,86.72 94.92,86.72 v1(95.78,85.86) ; 90.48,101.79 90.48,96 88.07,93.59 v1(68.93,93.59) ; 90.48,101.79 92.29,101.79 92.68,102.19 92.68,104.09 96.49,107.9 97.43,107.9 97.83,107.51 97.83,100.1 97.53,99.8 v1(97.53,99.06) ; 90.48,101.79 v1(90.48,102.53) v1(90.48,112.56) ; v1(118.44,101.87) 118.44,87.18 118.01,86.74 v1(118.01,72.13) v1(118.01,65.23)
MEMORY.RA13: length 256.6
  TOP w0.15: 94.14,115.73 92.01,115.73 91.75,115.99 U19.18 ; 94.14,115.73 94.14,90.33 93.55,89.73 ; 94.14,115.73 94.44,116.03 v1(94.44,117.27) ; 93.55,89.73 92.01,89.73 91.75,89.99 U17.18 ; 93.55,89.73 93.55,80.72 92.53,79.7 92.01,79.7 91.75,79.45 U16.18 ; U23.18 115.75,116.03 116.04,116.03 v1(116.04,115.29) ; U5.61 64.28,93.19 v1(63.54,93.93) v1(49.14,93.93) ; U20.18 v1(115.75,79.84) ; U22.18 115.75,102.62 v1(116.51,101.87) ; v1(91.95,102.6) 91.95,104.22 U18.18 ; U21.18 v1(115.75,92.69)
  BOTTOM w0.15: v1(91.95,102.6) 91.95,105.57 91.17,106.35 91.17,111.67 91.22,111.71 91.22,112.89 90.82,113.29 90.15,113.29 89.36,112.5 89.36,105.38 87.66,103.69 87.66,98.76 87.78,98.65 87.78,95.94 86.76,94.92 64.53,94.92 v1(63.54,93.93) ; v1(115.75,79.84) 115.75,91.95 v1(115.76,92.69) 116.51,93.44 v1(116.51,101.87) 116.51,107.84 116.04,108.31 v1(116.04,115.29) 114.06,117.27 v1(94.44,117.27) 92.87,117.27 92.13,118 52.03,118 48.73,114.7 48.73,95.08 49.14,94.67 v1(49.14,93.93)
MEMORY.RA14: length 227.3
  TOP w0.15: 116.47,96.27 116.01,96.27 115.75,96.01 U22.15 ; 116.47,96.27 116.5,96.23 v1(116.5,89.6) ; 116.47,96.27 116.47,97.83 115.84,98.47 112.31,98.47 111.42,99.35 111.42,105.28 111.55,105.41 115.36,105.41 115.75,105.8 U23.15 ; U19.15 91.75,106.56 91.5,106.31 90.88,106.31 89.73,105.16 v1(89.73,101.36) ; v1(89.75,72.76) 89.75,67.85 90.01,67.59 91.75,67.59 ; 91.75,67.59 U16.15 ; 91.75,67.59 v1(93.98,67.59) ; U21.15 115.75,84.41 v1(116.5,85.16) 117.84,83.82 117.84,74.35 116.96,73.46 116.09,73.46 115.45,72.82 ; 115.45,72.82 115.75,72.52 U20.15 ; 115.45,72.82 v1(112.46,72.82) ; U5.60 v1(64.31,91.92) ; U17.15 91.75,83.02 91.25,83.52 v1(91.25,84.52) 92.06,85.33 92.06,86.58 89.97,88.67 89.97,92.28 90.09,92.41 93.15,92.41 93.55,92.8 93.55,95.84 93.42,95.97 91.75,95.97 U18.15 91.75,93.59 89.99,93.59 89.73,93.85 v1(89.73,96.4)
  BOTTOM w0.15: v1(91.25,84.52) 90.2,84.52 89.69,84.02 89.69,80.06 89.75,80.01 v1(89.75,72.76) ; v1(93.98,67.59) 93.25,67.59 92.64,68.19 72.92,68.19 71.9,67.18 71.9,66.11 72.41,65.6 104.38,65.6 105.53,66.75 105.53,66.76 107.56,68.8 109.28,68.8 112.46,71.97 v1(112.46,72.82) ; v1(64.31,91.92) 67.01,94.62 86.93,94.62 88.08,95.76 88.08,100.15 87.96,100.26 87.96,102.64 88.36,103.03 89.1,103.03 89.73,102.4 v1(89.73,101.36) v1(89.73,96.4) ; v1(116.5,89.6) v1(116.5,85.16)
MEMORY.RA15: length 192.9
  TOP w0.15: U18.14 90.48,96.06 90.99,96.56 91.31,96.56 93.84,99.11 93.84,101.8 93.55,102.09 ; U16.14 90.48,69.97 ; 90.48,69.97 v1(90.48,71.6) ; 90.48,69.97 94.13,69.97 96.5,67.59 98.37,67.59 98.5,67.72 98.5,69.87 98.89,70.27 99.37,70.27 99.77,69.87 99.77,66.83 100.16,66.43 103.58,66.43 104.84,67.7 104.84,69.68 107.26,72.09 v1(114.48,72.09) U20.14 ; 93.55,102.09 93.55,110 92.75,110.79 92.14,110.79 90.48,109.14 U19.14 ; 93.55,102.09 93.25,101.8 92.71,101.8 88.64,97.73 87.12,97.73 86.86,97.47 v1(86.13,97.47) ; v1(115,83.7) 115,82.97 114.48,82.97 U21.14 ; 90.48,80.59 U17.14 ; 90.48,80.59 v1(90.48,79.86) ; 90.48,80.59 81.1,80.59 80.84,80.85 80.84,82.84 80.72,82.97 79.91,82.97 79.79,82.84 79.79,80.85 79.53,80.59 73.49,80.59 70.32,83.77 70.32,87.86 68.79,89.38 U5.58 63.01,89.38 62.81,89.18 v1(62.07,89.18) ; U23.14 114.48,106.65 114.99,106.14 v1(115,106.14) ; v1(115,96.27) 114.78,96.27 114.27,95.76 114.27,94.78 U22.14
  BOTTOM w0.15: v1(115,106.14) v1(115,96.27) v1(115,83.7) 115,73.98 114.48,73.46 v1(114.48,72.09) ; v1(86.13,97.47) 86.13,96.15 85.49,95.52 63.47,95.52 62.07,94.12 v1(62.07,89.18) ; v1(90.48,79.86) v1(90.48,71.6)
MEMORY.RCS0: length 65.1
  TOP w0.15: U16.6 80.33,67.54 77.66,64.87 67.4,64.87 67.01,65.27 67.01,65.94 67.4,66.34 70.06,66.34 70.49,65.91 73.27,65.91 73.67,66.3 73.67,66.97 73.27,67.37 70.25,67.37 63.65,73.97 63.65,79.77 ; 63.65,79.77 63.3,79.77 62.16,80.92 U5.51 ; 63.65,79.77 63.95,80.07 79.82,80.07 80.33,80.58 U17.6
MEMORY.RCS1: length 47.7
  TOP w0.15: v1(60.16,89.92) 69.41,89.92 70.05,90.55 v1(70.05,96.9) ; U5.50 60.89,84.19 60.38,84.69 v1(60.16,84.69) ; U19.6 v1(80.33,106.14) ; U18.6 v1(80.33,96.9)
  BOTTOM w0.15: v1(70.05,96.9) 79.59,96.9 ; 79.59,96.9 v1(80.33,96.9) ; 79.59,96.9 79.59,105.41 v1(80.33,106.14) ; v1(60.16,89.92) v1(60.16,84.69)
MEMORY.RCS2: length 71.3
  TOP w0.15: U5.49 59.62,80.83 62.95,77.5 62.95,74.13 70.44,66.64 v1(72.94,66.64) ; U20.6 104.33,69.89 103.82,70.4 v1(103.59,70.4) 103.59,79.34 104.33,80.07 U21.6
  BOTTOM w0.15: v1(72.94,66.64) 73.67,66.64 73.88,66.43 103.19,66.43 103.59,66.83 v1(103.59,70.4)
MEMORY.RCS3: length 154
  TOP w0.15: v1(116.81,110) 113.73,110 112.47,108.73 112.47,106.64 111.83,106 109.5,106 108.87,105.37 108.87,102.12 107.98,101.23 105.36,101.23 ; 105.36,101.23 105.36,98.81 104.33,97.78 U22.6 ; 105.36,101.23 105.06,101.53 105.06,105.57 104.33,106.31 U23.6 ; U5.48 58.35,84.33 60.13,86.11 v1(69.28,86.11)
  BOTTOM w0.15: v1(116.81,110) 116.81,109.27 117.24,108.83 117.24,78.82 115.91,77.48 115.91,70.8 109.81,64.7 72.33,64.7 69.28,67.75 v1(69.28,86.11)
MEMORY.RD0: length 243.3
  TOP w0.15: 117.55,89.17 118.75,87.97 118.75,68.87 117.47,67.59 111.71,67.59 ; 117.55,89.17 117.25,88.87 116.15,88.87 115,90.01 115,92.29 113.99,93.31 105.85,93.31 105.59,93.56 U22.7 v1(105.59,97.27) ; 117.55,89.17 117.55,97.23 114.37,100.4 v1(112.68,100.4) ; U5.81 57.08,112.76 57.31,113 v1(57.31,117.27) ; v1(92.5,109.76) 92.5,106.59 91.62,105.7 91.22,105.31 91.22,101.75 87.66,98.2 83.25,98.2 81.59,96.55 U18.7 ; U20.7 105.59,69.97 107.12,71.49 109.76,71.49 111.41,69.84 111.41,67.59 111.71,67.59 ; 111.71,67.59 111.71,66.8 110.44,65.53 83.37,65.53 81.59,67.31 U16.7
  BOTTOM w0.15: v1(57.31,117.27) 90.33,117.27 91.07,116.54 97.55,116.54 97.61,116.6 109.15,116.6 112.33,113.43 112.33,100.75 v1(112.68,100.4) ; v1(92.5,109.76) 96.24,113.49 101.73,113.49 102.24,112.99 102.24,93.92 103.89,92.27 104.71,92.27 105.59,93.16 v1(105.59,97.27)
MEMORY.RD1: length 140.1
  TOP w0.15: U22.10 109.41,95.97 109.69,95.97 v1(109.69,96.7) ; 85.3,94.78 84.88,94.78 84.88,89.99 85.14,89.73 85.53,89.73 85.92,90.13 85.92,92.15 86.94,93.16 v1(92.79,93.16) ; 85.3,94.78 v1(85.3,96.4) ; 85.3,94.78 U18.10 ; v1(61.62,99.3) 55.81,105.12 U5.82 ; U16.10 85.41,67.53 86.8,66.13 108.01,66.13 109.41,67.53 U20.10 v1(109.41,70.7)
  BOTTOM w0.15: 110.95,85.62 110.95,87.65 109.69,88.9 v1(109.69,96.7) ; 110.95,85.62 110.65,85.33 104.51,85.33 100.83,89.01 100.83,91.53 98.16,94.19 93.82,94.19 v1(92.79,93.16) ; 110.95,85.62 111.16,85.42 111.16,72.45 v1(109.41,70.7) ; v1(85.3,96.4) 84.93,96.02 64.9,96.02 v1(61.62,99.3)
MEMORY.RD2: length 231.9
  TOP w0.15: U20.23 109.41,76.39 110.04,75.75 v1(112.03,75.75) ; v1(72.95,73.75) 72.95,74.48 ; 72.95,74.48 73.25,74.78 83.74,74.78 84.89,75.92 84.89,76.28 85.41,76.8 U16.23 ; 72.95,74.48 v1(64.68,74.48) ; U18.23 85.41,103.11 85.88,102.64 v1(85.88,102.6) ; U22.23 109.41,102.97 109.85,102.52 v1(109.85,101.79) ; v1(54.54,108.24) U5.83
  BOTTOM w0.15: v1(112.03,75.75) 112.03,75.02 111.73,75.02 ; v1(109.85,101.79) 110.93,101.79 111.73,101 111.73,75.02 ; 58.01,108.24 58.01,83.76 59.4,82.36 59.46,82.36 63.65,78.17 63.65,75.51 v1(64.68,74.48) ; 58.01,108.24 80.24,108.24 v1(85.88,102.6) ; 58.01,108.24 v1(54.54,108.24) ; v1(72.95,73.75) 72.95,71.42 75.87,68.5 94.22,68.5 95.01,67.7 95.01,67.26 94.61,66.86 89.58,66.86 88.55,67.9 73.09,67.9 72.2,67.01 72.2,66.3 72.6,65.91 103.74,65.91 104.62,66.79 104.62,66.85 107.17,69.4 109.31,69.4 111.73,71.81 111.73,75.02
MEMORY.RD3: length 278.1
  TOP w0.15: v1(117.11,66.86) 117.86,66.86 118.75,65.97 118.75,64.89 118.35,64.5 66.83,64.5 65.59,65.73 v1(60.58,65.73) ; 105.59,74.72 U20.26 ; 105.59,74.72 v1(117.11,74.72) ; 105.59,74.72 v1(104.33,74.72) ; v1(116.92,111.46) 107.51,111.46 106.11,110.07 106.11,106.29 105.59,105.77 U22.26 ; v1(53.27,109.03) U5.84 53.27,114.89 57.08,118.7 86.8,118.7 87.31,118.2 87.31,112.07 86.91,111.67 86.81,111.67 85.92,110.78 85.92,106.64 85.29,106 82.1,106 81.59,105.5 U18.26 ; U16.26 81.59,79.41 87.07,79.41 87.19,79.28 87.19,77.39 88.85,75.74 95.29,75.74 95.68,75.34 95.68,74.69 95.18,74.18 v1(94.13,74.18)
  BOTTOM w0.15: v1(116.92,111.46) 116.92,110.73 117.14,110.73 117.54,110.33 117.54,76.86 117.11,76.44 v1(117.11,74.72) v1(117.11,66.86) ; v1(94.13,74.18) 103.05,74.18 103.59,74.72 v1(104.33,74.72) ; v1(53.27,109.03) 53.27,85.2 57.21,81.26 57.28,81.26 60.58,77.96 v1(60.58,65.73)
MEMORY.RD4: length 154
  TOP w0.15: U21.7 105.59,83 105.2,83.4 v1(104.31,83.4) ; v1(56.55,115.02) v1(56.55,109.31) ; U23.7 105.59,109.03 104.33,110.3 v1(100.78,110.3) ; v1(90.43,83.7) 88.83,85.3 83.25,85.3 81.59,83.65 U17.7 ; U5.1 v1(52,115.02) ; U19.7 v1(81.59,110.12)
  BOTTOM w0.15: v1(100.78,110.3) 98.84,108.36 98.26,108.36 ; v1(56.55,109.31) 57.67,110.43 80.45,110.43 80.77,110.12 v1(81.59,110.12) 81.59,109.28 81.85,109.02 87.17,109.02 88.76,110.61 88.76,112.45 89.9,113.59 91.01,113.59 91.52,113.08 91.52,111.41 91.47,111.37 91.47,109.25 92.36,108.36 98.26,108.36 ; v1(52,115.02) v1(56.55,115.02) ; 100.53,83.4 100.23,83.1 100.23,76.53 98.83,75.14 97.38,75.14 96.58,75.93 96.58,77.54 v1(90.43,83.7) ; 100.53,83.4 100.53,91.31 98.24,93.59 95.9,93.59 94.74,92.43 92.45,92.43 92.06,92.83 92.06,93.49 95.99,97.43 96.99,97.43 98.26,98.7 98.26,108.36 ; 100.53,83.4 v1(104.31,83.4)
MEMORY.RD5: length 188
  TOP w0.15: v1(88.48,84.56) 86.99,84.56 85.41,82.98 U17.10 ; v1(60.26,116.3) v1(60.26,113.55) ; U5.2 v1(50.73,113.55) ; v1(109.41,80.16) U21.10 109.41,86.62 109.91,87.12 109.92,87.12 111.19,88.39 111.19,92.37 110.56,93 v1(104.31,93) ; U23.10 v1(109.41,110.32) ; U19.10 85.41,109.64 83.37,111.67 v1(79.85,111.67)
  BOTTOM w0.15: v1(79.85,111.67) 62.14,111.67 v1(60.26,113.55) v1(50.73,113.55) ; v1(109.41,80.16) 108.67,80.16 107.96,80.87 105.55,80.87 101.99,77.31 101.99,77.25 99.58,74.84 96.28,74.84 95.08,76.04 94.46,76.04 92.55,74.13 92.55,72.52 90.9,70.87 90.06,70.87 88.29,72.64 88.29,79.88 88.59,80.19 88.59,83.72 88.48,83.83 v1(88.48,84.56) ; v1(104.31,93) 104.31,93.74 103.72,94.33 103.72,99.84 104.11,100.23 104.17,100.23 105.06,101.12 105.06,102.23 109.41,106.58 v1(109.41,110.32) 110.23,110.32 111.25,111.34 111.25,114.02 108.97,116.3 100.01,116.3 99.95,116.24 89.71,116.24 89.64,116.3 v1(60.26,116.3)
MEMORY.RD6: length 146.1
  TOP w0.15: v1(85.17,114.41) 85.17,115.8 85.41,116.03 U19.23 ; U21.23 109.41,89.44 108.96,89 v1(108.96,88.27) ; v1(97.02,107.17) v1(97.02,112.46) ; U23.23 v1(109.41,114.23) ; U17.23 85.41,92.45 86.42,93.46 88.21,93.46 88.47,93.72 88.47,96.29 89.61,97.43 90.88,97.43 v1(93.11,99.66) ; U5.3 v1(49.46,114.28)
  BOTTOM w0.15: v1(97.02,107.17) 93.11,103.26 v1(93.11,99.66) ; v1(109.41,114.23) 91.64,114.23 91.52,114.11 ; v1(108.96,88.27) 108.96,89.34 106.8,91.5 104.23,91.5 101.94,93.79 101.94,112.8 101.54,113.19 98.79,113.19 98.06,112.46 v1(97.02,112.46) 93.58,109.02 92.17,109.02 91.77,109.42 91.77,110.77 91.82,110.81 91.82,113.81 91.52,114.11 ; 91.52,114.11 86.2,114.11 85.9,114.41 v1(85.17,114.41) 61.66,114.41 61.53,114.28 v1(49.46,114.28)
MEMORY.RD7: length 154.9
  TOP w0.15: U19.26 v1(81.59,115.22) ; v1(101.21,112.46) 105.09,112.46 105.59,112.97 v1(105.59,115.27) U23.26 ; v1(77.7,97.63) 78.47,97.63 79.35,96.74 79.35,96.11 79.66,95.81 79.66,93.8 80.45,93 81.09,93 81.59,92.5 U17.26 ; U5.4 48.19,109.62 50.6,107.21 54.64,107.21 55.27,107.84 55.27,116.35 56.92,118 57.86,118 58.49,117.37 v1(58.49,116.54) 57.62,115.66 57.62,105.26 v1(62.45,100.43) ; U21.26 v1(105.59,89.6)
  BOTTOM w0.15: v1(105.59,115.27) 104.86,114.53 87.23,114.53 85.77,116 81.59,116 ; v1(58.49,116.54) 59.47,115.57 61.38,115.57 61.81,116 81.59,116 ; 81.59,116 v1(81.59,115.22) ; v1(62.45,100.43) 62.45,99.02 64.23,97.24 66.94,97.24 67.34,97.63 v1(77.7,97.63) ; v1(105.59,89.6) 104.6,90.6 104.56,90.6 101.51,93.65 101.51,111.43 101.21,111.73 v1(101.21,112.46)
MEMORY.RWE: length 230.9
  TOP w0.15: v1(114.17,110.73) 112.33,110.73 110.67,109.08 U23.11 110.67,106.56 110.42,106.31 108.47,106.31 108.33,106.16 v1(107.6,106.16) ; U16.11 86.67,69.97 ; 86.67,69.97 85.01,69.97 84.88,69.84 84.88,67.61 86.66,65.83 109.64,65.83 v1(110.67,66.86) U20.11 ; 86.67,69.97 v1(86.67,71.6) ; U22.11 110.67,96.03 112.07,97.43 v1(115.74,97.43) ; U17.11 86.67,83 87.07,83.4 v1(87.86,83.4) ; v1(86.67,105.91) U19.11 86.67,110.98 87.07,111.37 87.15,111.37 88.04,112.26 v1(88.04,115.27) ; U18.11 87.04,94.78 v1(87.04,96.47) ; v1(114.17,75.78) 114.17,76.7 113.95,76.92 113.95,79.15 113.69,79.41 112.72,79.41 112.47,79.15 112.47,77.16 112.34,77.03 111.56,77.03 111.3,77.29 111.3,79.39 110.67,80.02 U21.11 ; U5.56 v1(62.81,86.84)
  BOTTOM w0.15: v1(62.81,86.84) 62.81,94.33 63.7,95.22 85.79,95.22 v1(87.04,96.47) 87.04,97.67 87.31,97.94 87.31,104.55 86.67,105.18 v1(86.67,105.91) ; v1(107.6,106.16) 105.83,107.93 105.83,109.78 107.1,111.05 109.81,111.05 110.95,112.2 110.95,113.84 108.79,116 102.44,116 101.71,115.27 v1(88.04,115.27) ; v1(87.86,83.4) 87.86,72.78 v1(86.67,71.6) ; v1(115.74,97.43) 115.74,106.47 115.34,106.87 114.17,106.87 ; 114.17,106.87 v1(114.17,110.73) ; 114.17,106.87 v1(114.17,75.78) 114.17,74.35 113.52,73.7 113.52,69.7 v1(110.67,66.86)
MRD: length 38.8
  BOTTOM w0.15: U2.9 40.95,61.27 40.95,57.48 36.76,53.28 13.33,53.28 13.09,53.52 J1.46
MWR: length 47.9
  BOTTOM w0.15: U2.10 45.17,65.69 45.17,54.06 43.91,52.8 43.48,52.8 41.43,50.74 33.1,50.74 32.86,50.99 13.1,50.99 13.09,50.98 J1.45
N00036_DATA_DAAMP: length 32.6
  TOP w0.15: U8.8 v1(85.13,42.17) ; U10.5 v1(84.97,44.41) ; U8.5 v1(85.13,38.36)
  BOTTOM w0.15: 90.67,34.83 90.67,35.5 R7.1 ; 90.67,34.83 90.67,34.52 86.83,34.52 86.19,35.16 86.19,37.7 86.49,38 ; 90.67,34.83 90.99,34.83 92.58,33.24 92.58,31.3 L4.2 ; R6.1 86.49,38 ; 86.49,38 86.13,38.36 v1(85.13,38.36) v1(85.13,42.17) 85.13,43.51 84.97,43.67 v1(84.97,44.41)
N00036_DATA_DAAMP1: length 34
  TOP w0.15: U13.5 v1(85.27,24.48) ; U11.8 v1(84.54,22.25) ; U11.5 v1(85.22,18.44)
  BOTTOM w0.15: L6.2 93.05,10.91 93.05,13.5 90.97,15.58 ; 86.63,18.44 86.63,19.08 87.77,20.22 90.09,20.22 90.97,19.33 90.97,15.58 ; 86.63,18.44 v1(85.22,18.44) 85.22,19.18 85.27,19.23 85.27,22.25 ; 86.63,18.44 86.99,18.08 R8.1 ; R9.1 90.97,15.58 ; v1(85.27,24.48) 85.27,22.25 ; 85.27,22.25 v1(84.54,22.25)
N00038_DATA_DAAMP: length 25.1
  TOP w0.15: U8.4 v1(84.35,37.09)
  BOTTOM w0.15: 91.08,31.61 85.75,31.61 84.35,33.01 v1(84.35,37.09) ; 91.08,31.61 91.38,31.61 91.38,33 C8.1 ; 91.08,31.61 91.08,31.19 93.74,28.52 94.85,28.52 95.36,29.03 95.36,31.02 L3.2
N00038_DATA_DAAMP1: length 15.2
  TOP w0.15: U11.4 83.97,17.17 84.77,16.38 84.77,16.25 87.94,13.08 v1(91.72,13.08) 92.72,12.08 L5.2
  BOTTOM w0.15: C11.1 v1(91.72,13.08)
N00044_DATA_DAAMP: length 8.5
  TOP w0.15: U10.1 90.77,40.59 90.77,39.97 91.4,39.34 v1(92.31,39.34)
  BOTTOM w0.15: v1(92.31,39.34) 93.04,39.34 93.64,39.93 U9.2
N00044_DATA_DAAMP1: length 5.2
  TOP w0.15: U13.1 94.06,20.67 94.72,20.01 96.93,20.01
N00060_DATA_DAAMP: length 20
  TOP w0.15: U8.6 v1(87.06,39.64)
  BOTTOM w0.15: U9.3 97.55,37.63 92.93,37.63 91.28,39.28 91.28,39.47 89.12,41.63 88.21,41.63 87.06,40.48 v1(87.06,39.64)
N00060_DATA_DAAMP1: length 20
  TOP w0.15: U12.3 96.1,16.25 86.84,16.25 85.95,17.14 85.95,18.82 85.06,19.71 U11.6
N282866_DATA_DAAMP: length 6.4
  TOP w0.15: U10.8 v1(88.92,40.59)
  BOTTOM w0.15: v1(88.92,40.59) 89.66,40.59 90.67,39.58 90.67,38 R6.2
N282866_DATA_DAAMP1: length 6.7
  TOP w0.15: U13.8 88.09,20.67 v1(88.09,19.49)
  BOTTOM w0.15: R8.2 90.67,18.08 90.67,19.09 90.28,19.49 v1(88.09,19.49)
N282912_DATA_DAAMP: length 10.3
  TOP w0.15: v1(86.93,35.5) 89.95,38.52 89.95,41.07 90.74,41.86 U10.2
  BOTTOM w0.15: R7.2 v1(86.93,35.5)
N282912_DATA_DAAMP1: length 10.6
  TOP w0.15: U13.2 90.72,21.94 90.52,21.74 90.52,20.08 87.72,17.29 v1(86.89,17.29)
  BOTTOM w0.15: v1(86.89,17.29) 86.89,15.98 87.29,15.58 R9.2
NCS: length 14.5
  TOP w0.15: U7.4 30.84,108.97 38.79,108.97 39.3,109.47 U5.11
OE: length 33.3
  TOP w0.15: U5.32 39.31,84.3 39.56,84.55 39.56,84.62 40.45,85.51 41.06,85.51 41.82,86.27 41.82,98.81 39.28,101.34 32.44,101.34 30.21,103.58 U7.3
OUTA: length 18.3
  TOP w0.15: L1.1 94.5,43.27 97.55,46.32 100.05,46.32 101.07,45.3 U9.6
OUTB: length 18.3
  BOTTOM w0.15: L2.1 94.5,23.35 97.55,26.4 100.05,26.4 101.07,25.38 U12.6
Q0: length 6
  TOP w0.15: U6.18 72.91,60.67 73.09,60.5 R1.1
Q1: length 5.9
  TOP w0.15: R2.1 73.05,58 72.91,58.13 U6.16
Q2: length 5.9
  TOP w0.15: R3.1 73.01,55.5 72.91,55.59 U6.14
Q3: length 5.9
  TOP w0.15: R4.1 72.97,53 72.91,53.05 U6.12
RDY: length 41
  TOP w0.15: v1(37.68,58.61) 37.68,47.85 U2.23
  BOTTOM w0.15: J1.50 13.69,62.07 13.69,61.16 16.49,58.37 37.44,58.37 v1(37.68,58.61)
RESET: length 59
  TOP w0.15: U5.15 v1(31.16,105.89)
  BOTTOM w0.15: J1.53 10.77,72.61 10.77,99.72 13.31,102.27 28.36,102.27 31.16,105.06 v1(31.16,105.89)
SEL: length 50.9
  TOP w0.15: U5.13 v1(44.75,108.43)
  BOTTOM w0.15: v1(44.75,108.43) 44.75,101.8 46.41,100.15 46.41,96.58 40.7,90.87 40.59,90.87 37.55,87.82 37.55,70.58 U2.14
V+12: length 195.1
  TOP w0.4: U13.4 90.74,24.48 v1(90.74,25.9) 92.46,25.9 93.09,26.52 99,26.52 ; v1(103.47,33.17) 103.47,28.94 101.06,26.52 99,26.52 ; U12.7 99,26.52 ; v1(44.74,96.31) 46.01,95.04 v1(58.99,95.04) ; J1.64 J1.63 ; U10.4 v1(89.92,44.41)
  BOTTOM w0.4: v1(90.74,25.9) 81.54,25.9 79,23.36 C12.1 ; v1(44.74,96.31) 13.86,96.31 13.47,96.7 J1.63 ; 78.7,43.61 75.08,43.61 65.81,52.88 65.81,77.45 60.22,83.04 60.13,83.04 58.99,84.18 v1(58.99,95.04) ; 78.7,43.61 79,43.31 C9.1 ; 78.7,43.61 80.61,45.51 89.62,45.51 ; 99,46.45 90.55,46.45 89.62,45.51 ; 99,46.45 U9.7 ; 99,46.45 100.93,46.45 103.47,43.91 v1(103.47,33.17) ; 89.62,45.51 89.92,45.51 v1(89.92,44.41)
VCLKA: length 84.2
  TOP w0.2: U14.11 67.77,33.28 67.14,33.92 v1(67.14,41.57) 74.56,41.57 75.07,42.08 75.07,44.32 74.67,44.72 U8.11 ; v1(60.58,63.01) 43.87,63.01 40.57,66.31 U5.34
  BOTTOM w0.2: v1(67.14,41.57) 62.04,46.67 62.04,55.66 60.58,57.11 v1(60.58,63.01)
VCLKC: length 100
  TOP w0.2: U15.11 67.81,13.36 66.66,14.51 v1(66.66,23.58) 66.66,25.2 67.06,25.6 70.89,25.6 71.69,24.79 U11.11 ; v1(49.7,29.44) v1(49.7,31.77)
  BOTTOM w0.2: v1(49.7,29.44) 60.8,29.44 v1(66.66,23.58) ; R5.2 49.7,88.5 v1(49.7,31.77)
VD0: length 88.8
  TOP w0.15: U14.2 56.38,43.45 56.08,43.74 ; 56.08,43.74 55.65,43.31 v1(55.65,27.5) ; 56.08,43.74 56.08,61.95 ; U15.2 v1(57.79,23.52) ; U6.2 56.08,61.95 ; 56.08,61.95 v1(46.92,61.95) ; v1(46.92,80.71) U5.39
  BOTTOM w0.15: v1(46.92,61.95) v1(46.92,80.71) ; R13.2 v1(55.65,27.5) 57.79,25.36 v1(57.79,23.52)
VD1: length 100.7
  TOP w0.15: U6.3 60.98,60.67 ; 60.98,60.67 60.98,61.12 61.18,61.31 v1(64.13,61.31) ; 60.98,60.67 57.76,60.67 56.48,59.41 56.48,50.96 60.3,47.15 60.31,47.15 61.2,46.26 61.2,42.17 U14.3 58.39,42.17 56.48,40.27 56.48,26.27 55.22,25 v1(54.32,25) ; U15.3 v1(57.79,22.25) ; v1(54.9,84.79) 48.59,84.79 48.19,84.4 U5.40
  BOTTOM w0.15: R17.2 v1(54.32,25) 54.32,24.16 56.23,22.25 v1(57.79,22.25) ; v1(54.9,84.79) 58.03,81.66 58.89,81.66 62.95,77.6 62.95,62.49 v1(64.13,61.31)
VD2: length 87.4
  TOP w0.15: v1(57.72,71.44) 56.83,71.44 49.46,78.8 U5.41 ; 56.59,22.5 56.89,22.8 56.89,39.32 58.47,40.91 U14.4 61.2,40.91 61.99,41.7 61.99,47.5 60.34,49.15 60.31,49.15 56.89,52.58 56.89,58.57 v1(57.72,59.41) U6.4 ; 56.59,22.5 v1(49.72,22.5) ; 56.59,22.5 56.59,22 57.6,20.98 U15.4
  BOTTOM w0.15: R12.2 v1(49.72,22.5) ; v1(57.72,71.44) v1(57.72,59.41)
VD3: length 96.8
  TOP w0.15: U6.5 v1(64.13,58.13) 64.13,40.2 63.26,39.34 ; 63.26,39.34 62.96,39.64 U14.5 ; 63.26,39.34 v1(63.26,20) ; v1(57.98,20) 58.05,19.93 59.84,19.93 U15.5 ; v1(61.82,77.44) 51.62,77.44 50.73,78.33 U5.42
  BOTTOM w0.15: v1(64.13,58.13) 61.82,60.45 v1(61.82,77.44) ; v1(63.26,20) v1(57.98,20) R16.2
VD4: length 94.5
  TOP w0.15: U14.6 58.48,38.36 58.09,37.97 v1(58.09,31.82) 58.09,29.64 60.37,27.35 60.4,27.35 61.2,26.55 61.2,18.44 U15.6 v1(53.72,18.44) ; U5.43 v1(52,78.33) ; U6.6 v1(58.52,56.87)
  BOTTOM w0.15: v1(52,78.33) 52,61.82 57.25,56.56 ; R11.2 52.77,17.5 v1(53.72,18.44) ; 57.25,56.56 57.55,56.87 v1(58.52,56.87) ; 57.25,56.56 57.25,32.66 v1(58.09,31.82)
VD5: length 96.6
  TOP w0.15: v1(53.58,79.6) 53.58,80.83 53.27,81.14 U5.44 ; U15.7 61.59,17.17 v1(62.43,18.01) v1(62.43,33.76) 62.43,36.21 61.54,37.09 U14.7 ; U6.7 v1(58.92,55.59)
  BOTTOM w0.15: R15.2 59.42,15 v1(62.43,18.01) ; v1(62.43,33.76) 60.67,35.51 60.67,47.47 58.92,49.23 v1(58.92,55.59) 59.35,56.03 59.35,75.15 54.91,79.6 v1(53.58,79.6)
VD6: length 89.7
  TOP w0.15: U14.8 v1(61.59,35.83) 61.59,18.2 61.2,17.8 58.61,17.8 58.48,17.68 58.48,15.9 ; U5.45 v1(54.54,78.7) ; v1(57.72,58.13) 57.72,57.3 57.69,57.27 57.69,55.59 58.95,54.33 v1(60.78,54.33) U6.8 ; U15.8 58.48,15.9 ; 58.48,15.9 56.72,15.9 v1(53.32,12.5)
  BOTTOM w0.15: v1(54.54,78.7) 54.54,61.31 v1(57.72,58.13) ; v1(60.78,54.33) 60.78,53.42 61.59,52.61 v1(61.59,35.83) ; R10.2 v1(53.32,12.5)
VD7: length 110.2
  TOP w0.15: U5.46 v1(55.81,80.43) ; v1(59.75,53.05) U6.9 63.7,53.05 63.7,42.8 61.16,40.27 58.61,40.27 58.48,40.14 58.48,39.19 58.68,39 61.07,39 61.2,38.87 61.2,37.92 61,37.73 58.61,37.73 58.48,37.6 58.48,34.55 U14.9 61.2,34.55 61.2,29.45 60.76,29.02 v1(60.76,28.18) ; U15.9 v1(64.83,14.63)
  BOTTOM w0.15: v1(60.76,28.18) 64.83,24.12 v1(64.83,14.63) 60.2,10 R14.2 ; v1(55.81,80.43) 59.75,76.49 v1(59.75,53.05)
VREF: length 25.4
  TOP w0.15: L5.1 102.97,11.1 102.97,11.01 103.48,10.5 R18.1
  BOTTOM w0.15: L3.1 104.12,29.88 104.12,14.2 L5.1
WAIT: length 49.7
  TOP w0.15: v1(34.47,77.02) 35.24,77.02 39.3,81.08 U5.33
  BOTTOM w0.15: v1(34.47,77.02) 34.47,64.2 30.41,60.14 27.74,60.14 26.56,58.96 23.45,58.96 21.67,60.74 21.67,62.72 19.64,64.75 19.52,64.75 18.05,66.22 J1.51
WSTAT: length 41.7
  TOP w0.15: U6.11 v1(68.55,51.78) ; U5.57 v1(68.55,88.11)
  BOTTOM w0.15: v1(68.55,51.78) v1(68.55,88.11)
N14843: length 3.2
  BOTTOM w0.15: C19.1 R16.1
N14849: length 3.2
  BOTTOM w0.15: C15.1 R12.1
N14853: length 3.2
  BOTTOM w0.15: C20.1 R17.1
N14855: length 3.2
  BOTTOM w0.15: C16.1 R13.1
N15143: length 3.2
  BOTTOM w0.15: C17.1 R14.1
N15151: length 3.2
  BOTTOM w0.15: C13.1 R10.1
N15155: length 3.2
  BOTTOM w0.15: C18.1 R15.1
N15161: length 3.2
  BOTTOM w0.15: C14.1 R11.1
N58063: length 4.2
  TOP w0.15: U8.12 U14.19
N58118: length 4.2
  TOP w0.15: U8.13 U14.18
N58173: length 4.2
  TOP w0.15: U8.14 U14.17
N58228: length 4.2
  TOP w0.15: U8.15 U14.16
N58283: length 4.2
  TOP w0.15: U8.16 U14.15
N58338: length 4.2
  TOP w0.15: U8.17 U14.14
N58393: length 4.2
  TOP w0.15: U8.18 U14.13
N58448: length 4.2
  TOP w0.15: U8.19 U14.12
N58834: length 4.2
  TOP w0.15: U11.12 U15.19
N58889: length 4.2
  TOP w0.15: U11.13 U15.18
N58944: length 4.2
  TOP w0.15: U11.14 U15.17
N58999: length 4.2
  TOP w0.15: U11.15 U15.16
N59054: length 4.2
  TOP w0.15: U11.16 U15.15
N59109: length 4.2
  TOP w0.15: U11.17 U15.14
N59164: length 4.2
  TOP w0.15: U11.18 U15.13
N59219: length 4.2
  TOP w0.15: U11.19 U15.12
N409523: length 8.4
  TOP w0.15: U5.37 v1(44.38,88.5)
  BOTTOM w0.15: R5.1 v1(44.38,88.5)

## Copper pours and planes (outline as drawn)
GND on GND1, GND2: 21,1.41 21,9 20.41,10.41 19,11 1.41,11 1,11.41 1,108.59 1.41,109 19,109 20.41,109.59 21,111 21,118.59 21.41,119 118.59,119 119,118.59 119,1.41 118.59,1 21.41,1 ; 2 cut-outs
VCC on VCC1, VCC2: 21,1.41 21,9 20.41,10.41 19,11 1.41,11 1,11.41 1,108.59 1.41,109 19,109 20.41,109.59 21,111 21,118.59 21.41,119 118.59,119 119,118.59 119,1.41 118.59,1 21.41,1 ; 2 cut-outs
